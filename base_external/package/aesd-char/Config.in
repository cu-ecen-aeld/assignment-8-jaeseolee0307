## base_external/package/aesd-char/Config.in
```kconfig
config BR2_PACKAGE_AESDCHAR
	bool "aesd-char"
	depends on BR2_LINUX_KERNEL
	help
	  aesdchar package for assignment 8
```
